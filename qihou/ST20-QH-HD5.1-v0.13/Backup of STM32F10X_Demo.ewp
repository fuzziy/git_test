# IAR project Backup of STM32F10X_Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: App; BSP; CMSIS\CoreSupport; STM32F10x_StdPeriph_Driver\inc; CMSIS\DeviceSupport; BSP\LED; CMSIS\DeviceSupport; uC-CFG; uC-CPU; uC-LIB\Ports; uC-LIB; uCOS-II\Ports; uCOS-II\Source; BSP\BSP_OS; BSP\MY MODBUS; BSP\PARA; BSP\RS485_1; BSP\TIMER; MODBUS\modbus\ascii; MODBUS\modbus\functions; MODBUS\modbus\include; MODBUS\modbus\rtu; MODBUS\port; MODBUS2\port; BSP; BSP\RS485_2; MODBUS2; MODBUS2\modbus; BSP\CALCULATE; BLE\port; BSP\RS485_3; BLE\modbus; BSP\DELAY; BSP\IIC; BSP\MCP3421; BSP\ADC; BSP\RX8025; BSP\AT24CXX; BSP\DI; BSP\DO; BSP\QI HOU; BSP\DAC; BSP\IWDG; BSP\74HC405X; BSP\AI; Wrappers\QI HOU; Wrappers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F10X_Demo.hex
  ILINK.IlinkOutputFile: STM32F10X_Demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    App/: main.c stm32f10x_it.c
  group BLE-MODBUS/Ports
    BLE/port/: port3.c port3event.c port3serial.c port3timer.c
  group BLE-MODBUS/Source
    BLE/modbus/: mb3.c mb3funcholding.c mb3rtu.c
  group BSP
    BSP/AT24CXX/: 24cxx.c
    BSP/74HC405X/: 74hc405x.c
    BSP/ADC/: adc.c
    BSP/AI/: ai.c
    BSP/: bsp.c bsp.h bsp_int.c sys.h
    BSP/BSP_OS/: bsp_os.c bsp_os.h
    BSP/CALCULATE/: calculate.c
    BSP/DAC/: dac.c
    BSP/DELAY/: delay.c
    BSP/DI/: di.c
    BSP/DO/: do.c
    BSP/IWDG/: iwdg.c
    BSP/LED/: led.c
    BSP/MCP3421/: mcp3421.c
    BSP/MY MODBUS/: my_modbus.c
    BSP/RS485_1/: rs485_1.c
    BSP/RS485_2/: rs485_2.c
    BSP/RS485_3/: rs485_3.c
    BSP/RX8025/: rx8025.c
    BSP/IIC/: sim_i2c.c
    BSP/TIMER/: timer.c
  group CMSIS
    CMSIS/DeviceSupport/: system_stm32f10x.c
  group MODBUS1/Ports
    MODBUS/port/: port.c portevent.c portserial.c porttimer.c
  group MODBUS1/Source
    MODBUS/modbus/: mb.c
    MODBUS/modbus/ascii/: mbascii.c
    MODBUS/modbus/rtu/: mbcrc.c mbrtu.c
    MODBUS/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group MODBUS2/Ports
    MODBUS2/port/: port2.c port2.h port2event.c port2serial.c port2timer.c
  group MODBUS2/Source
    MODBUS2/modbus/: mb2.c mb2funcholding.c mb2rtu.c
  group Startup
    CMSIS/DeviceSupport/startup/: startup_stm32f10x_hd.s
  group STM32F10x_StdPeriph_Driver
    STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group uC/CFG
    uC-CFG/: app_cfg.h app_hooks.c cpu_cfg.h includes.h lib_cfg.h os_cfg.h
  group uC/CPU
    uC-CPU/: cpu.h cpu_a.asm cpu_c.c cpu_core.c cpu_core.h cpu_def.h
  group uC/LIB
    uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/LIB/Port
    uC-LIB/Ports/: lib_mem_a.asm
  group uC/OS-II/Ports
    uCOS-II/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC/OS-II/Source
    uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group Wrappers
    Wrappers/QI HOU/: qihou.c qihou_para.c
    Wrappers/: wrappers.c
